options:
  parameters:
    author: Fischer Benjamin, Mladenov Tom
    description: UHF demodulator and decoder application for the ESA OPS-SAT mission
    generate_options: qt_gui
    id: os_demod_decode
    output_language: python
    title: OPS-SAT UHF demodulator/decoder
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: firdes.gaussian (1.5, 2* (samp_rate / baud_rate) , 0.5, 12)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '57600'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: note_0
  id: note
  parameters:
    note: GMSK9k6
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    name: '"OPS-SAT UHF BEACON"'
    showports: 'True'
    type: complex
    update_time: '0.03'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: norad
    iq: 'True'
    norad: '44878'
    samp_rate: samp_rate
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: tm_fwd
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:38211
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [pdu_pdu_to_tagged_stream_1, '0', zeromq_pub_sink_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, log]
- [satellites_satellite_decoder_0, out, pdu_pdu_to_tagged_stream_1, pdus]
- [virtual_source_0_0_1, '0', satellites_submit_0, in]
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [zeromq_sub_source_0, '0', satellites_satellite_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
